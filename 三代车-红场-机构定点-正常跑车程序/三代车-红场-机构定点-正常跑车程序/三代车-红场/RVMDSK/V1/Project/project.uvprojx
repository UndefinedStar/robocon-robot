# Keil uVision project project.uvprojx, settings and files
target Track_line (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/src/: main.c stm32f4xx_it.c led.c delay.c OV7725.c sccb.c usart.c can1.c MyDataProcess.c pid.c ili9320_api.c led_show.c ili9325.c queue.c visual_scope.c Kalman.c PS2.c
    ./: image.c
  group LIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_can.c
    ../User/src/: stm32f4xx_dma.c stm32f4xx_dcmi.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/Startup/: startup_stm32f4xx.s
software components: CMSIS:CORE 5.0.1
