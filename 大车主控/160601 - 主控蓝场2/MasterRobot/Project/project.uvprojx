# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Startup;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User\inc;..\uCOSII\PORT;..\uCOSII\CORE;..\uCOSII\CONFIG;..\GeneralFunction\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/src/: main.c stm32f4xx_it.c beep.c led.c led8.c delay.c rundriver.c run.c pid.c can1.c queue.c usart1.c ili9320_api.c key.c can2.c usart2.c lcd.c usart4.c motor.c flash.c tim.c exti.c ili9320.c
  group GeneralFunction
    ../GeneralFunction/src/: visual_scope.c MyMath.c MyDataProcess.c
  group LIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_flash.c stm32f4xx_syscfg.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/Startup/: startup_stm32f4xx.s
  group uCOS/CORE
    ../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS/PORT
    ../uCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/CONFIG
    ../uCOSII/CONFIG/: includes.h os_cfg.h
  group Read me
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
