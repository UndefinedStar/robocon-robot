# Keil uVision project OV7670.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OV7670
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\FWlib\inc;.\USER;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./USER/: delay.c GUI_32.c I2C.c ILI9325_32.c main.c OV7670.c stm32f10x_it.c sys.c Nvic_Exit.c led.c PictureAnalyse.c Tim1.c
  group LIB
    ./FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group STARTCODE
    ./CMSIS/startup/: startup_stm32f10x_hd.s
